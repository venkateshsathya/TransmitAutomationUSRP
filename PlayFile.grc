<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>PlayFile</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrier</value></param>
<param><key>value</key><value>900000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.25e6/5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>txgain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/venkatesh/Desktop/USRPProject/DataCollect/IQSamples/Transmit/18thAugustCorrectScalingNoSNRSetNoChannelEffects/64QAM18thAug2019EvenReal.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>file</key><value>/home/venkatesh/Desktop/USRPProject/DataCollect/IQSamples/Transmit/18thAugustCorrectScalingNoSNRSetNoChannelEffects/64QAM18thAug2019EvenImag.bin</value></param>
<param><key>type</key><value>float</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>1250000*1000</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>digital_glfsr_source_x</key>
<param><key>id</key><value>digital_glfsr_source_x_0</value></param>
<param><key>degree</key><value>30</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>mask</key><value>0</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>seed</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>carrier</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>txgain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>carrier</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>txgain</value></param>
<param><key>ant2</key><value>TX/RX</value></param>
<param><key>center_freq2</key><value>carrier</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>txgain</value></param>
<param><key>ant3</key><value>TX/RX</value></param>
<param><key>center_freq3</key><value>carrier</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>txgain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>"addr=192.168.10.2"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>blocks_null_source_0_1</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
